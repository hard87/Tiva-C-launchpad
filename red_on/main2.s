

SYSCTL_RCGCGPIO_R EQU 0x400FE608
GPIO_PORTN_DIR_R  EQU 0x40064400
GPIO_PORTN_DEN_R  EQU 0x40064420
GPIO_PORTN_DATA_R EQU 0x40064000
				
				AREA	|.text|,CODE,READONLY,ALIGN=2
				THUMB
				EXPORT __main
					
					
__main
		BL		GPION_Init
		
loop	BL 		LIGHT_ON
		B		loop
		
GPION_Init
		LDR R1,=SYSCTL_RCGCGPIO_R
		LDR R0,[R1]
		ORR R0,R0,#0x1000
		STR R0,[R1]
		
		LDR R1,=GPIO_PORTN_DIR_R
		MOV R0,#0x02
		STR R0,[R1]
		
		LDR R1,=GPIO_PORTN_DEN_R
		MOV R0,#0x02
		STR R0,[R1]
		
		BX LR

LIGHT_ON
		LDR R1,=GPIO_PORTN_DATA_R
		MOV R0,#0x02
		STR R0,[R1]
		BX LR
		
		ALIGN
		END
			